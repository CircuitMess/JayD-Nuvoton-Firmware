# Keil uVision project i2c_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E616 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(16000000)
  output: i2c_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51 main.c buttonHandler.c sliderHandler.c encoderHandler.c listHandler.c
